# Avoid using ttyS0 as default serial console
SERIAL_CONSOLES = "115200;ttyS1"